	AREA max,CODE,READONLY
	ENTRY
main
	LDR R0,VALUE
	LDR R1,[R0],#04
	LDR R4,[R0],#04
	SUB R1,#01
LOOP
	LDR R3,[R0],#04
	CMP R4,R3
	BHI LOOP2
	SUB R1,#01
	CMP R1,#00
	BNE LOOP
	LDR R2,RESULT
	STR R4,[R2],#04
LOOP2
	MOV R5,R4
	MOV R4,R3
	MOV R3,R5
	CMP R1,#00
	BNE LOOP
STOP	B STOP
VALUE	DCD &40000000
RESULT	DCD &4000000F
		END
	
	
	
	